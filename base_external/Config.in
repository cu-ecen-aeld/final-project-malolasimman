## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_project_base_PATH/package/final/Config.in"
source "$BR2_EXTERNAL_project_base_PATH/package/LCD/Config.in"
```
